# Keil uVision project HJduino.uvprojx, settings and files
target armdemo (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: htdemo +hex
  c flags: OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: .\CMSIS;.\StdPeriph_Driver\inc;.\StdPeriph_Driver\src;.\;.\SYSTEM\sys;.\SYSTEM\usart;.\HARDWARE\IRCtrol;.\HARDWARE\motor;.\HARDWARE\SpeedControl
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group App
    ./: main.c stm32f10x_it.c interface.c
  group StdPeriph_Driver
    ./StdPeriph_Driver/src/: misc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_crc.c stm32f10x_dbgmcu.c
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group RVMDK
    ./: startup_stm32f10x_hd.s
  group SYSTEM
    ./SYSTEM/sys/: sys.c
    ./SYSTEM/usart/: usart.c
  group HARDWARE
    ./HARDWARE/IRCtrol/: IRCtrol.c
    ./HARDWARE/motor/: motor.c
    ./HARDWARE/SpeedControl/: SpeedCtrol.c
